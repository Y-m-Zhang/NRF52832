# Keil uVision project ADS1292R.uvprojx, settings and files
target nrf52832_xxaa (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.2
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: lis3dh +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: BOARD_PCA10040 NRF52 SWI_DISABLE0
  c include: ..\components\drivers_nrf\delay;..\components\drivers_nrf\hal;..\components\drivers_nrf\common;..\components\drivers_nrf\uart;..\bsp;..\..;..\components\libraries\uart;..\components\libraries\util;..\components\drivers_nrf\config;..\components\drivers_nrf\nrf_soc_nosd;..\components\toolchain;..\components\libraries\fifo;..\config;..\components\drivers_nrf\spi_master;..\ikm;..\components\drivers_nrf\rtt
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application
    ./: main.c
  group nRF_Drivers
    ../components/drivers_nrf/delay/: nrf_delay.c
    ../components/drivers_nrf/uart/: nrf_drv_uart.c
    ../components/drivers_nrf/common/: nrf_drv_common.c
    ../components/drivers_nrf/spi_master/: nrf_drv_spi.c
    ../components/drivers_nrf/rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT.c SEGGER_RTT_printf.c
  group nRF_Libraries
    ../components/libraries/uart/: app_uart_fifo.c retarget.c
    ../components/libraries/util/: app_util_platform.c app_error.c nrf_assert.c app_error_weak.c
    ../components/libraries/fifo/: app_fifo.c
  group ikm_Drives
    ../ikm/: ads1292r.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.9.0
